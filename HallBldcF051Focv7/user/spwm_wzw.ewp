# IAR project spwm_wzw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051R8 ST STM32F051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: ../user; ../drive; ../lib/inc; ../CMSIS; ../hall_bldc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spwm_wzw.bin
  ILINK.IlinkOutputFile: spwm_wzw.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f030x6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group bldc_driver/include
    ../hall_bldc/: bldc.h bldc_const.h bldc_global.h bldc_hall_delay.h bldc_hall_exti.h bldc_pwm.h
  group bldc_driver/source
    ../hall_bldc/: bldc.c bldc_global.c bldc_hall_adc.c bldc_hall_delay.c bldc_hall_exti.c bldc_hall_timer.c bldc_pwm.c
  group cmsis
    ../cmsis/: stm32f0xx.h system_stm32f0xx.h
  group lib
    ../lib/src/: stm32f0xx_adc.c stm32f0xx_comp.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group startup
    ../startup/: startup_stm32f0xx.s
  group user
    ./: main.c stm32f0xx_conf.h stm32f0xx_it.c system_stm32f0xx.c
